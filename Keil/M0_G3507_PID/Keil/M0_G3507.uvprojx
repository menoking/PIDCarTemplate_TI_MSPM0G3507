# Keil uVision project M0_G3507.uvprojx, settings and files
target M0_G3507 (6190000::V6.19::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: M0_G3507 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MSPM0G3507__
  c include: ..\;..\..\..\source\third_party\CMSIS\Core\Include;..\MCU_Drivers;..\User;..\Hardware;..\Hardware\mpu6050
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group MCU_Drivers
    ../MCU_Drivers/: ti_msp_dl_config.c ti_msp_dl_config.h
  group Driverlib
    ../MCU_Drivers/: driverlib.a
  group User
    ../User/: main.c delay.c usart.c
    ../MCU_Drivers/: M0_G3507.syscfg
    ./: startup_mspm0g350x_uvision.s
  group Hardware
    ../Hardware/: key.c oled.c Encoder.c motor_ctrl.c protocol.c gw_gray.c
    ../Hardware/mpu6050/: mpu6050.c
